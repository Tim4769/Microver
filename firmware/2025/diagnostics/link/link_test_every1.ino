/*
  Arduino Every 1 Link Test (D11/D12 UART)
*/

#include <Arduino.h>
#include <SoftwareSerial.h>
#include <stdio.h>

const uint8_t LINK_RX_PIN = 12;  // D12 receives from Arduino Every 2
const uint8_t LINK_TX_PIN = 11;  // D11 sends to Arduino Every 2
const unsigned long LINK_BAUD = 38400;
const unsigned long LINK_TIMEOUT_MS = 250;
SoftwareSerial linkSerial(LINK_RX_PIN, LINK_TX_PIN);

uint8_t seq = 0;
uint32_t errCount = 0;

bool readLine(char *buffer, size_t length, unsigned long timeoutMs) {
  size_t index = 0;
  const unsigned long start = millis();
  while ((millis() - start) < timeoutMs) {
    while (linkSerial.available()) {
      const char c = linkSerial.read();
      if (c == '
') {
        buffer[index] = '';
        return true;
      }
      if (index < length - 1) {
        buffer[index++] = c;
      }
    }
  }
  buffer[index] = '';
  return false;
}

void setup() {
  Serial.begin(115200);
  while (!Serial) {
    ;
  }
  pinMode(LINK_TX_PIN, OUTPUT);
  pinMode(LINK_RX_PIN, INPUT);
  linkSerial.begin(LINK_BAUD);
  linkSerial.listen();
  Serial.println(F("Link test master"));
}

void loop() {
  while (linkSerial.available()) {
    linkSerial.read();
  }

  const uint8_t payload = seq++;
  linkSerial.print(F("PING,"));
  linkSerial.print(payload);
  linkSerial.print('
');

  char lineBuffer[24];
  if (!readLine(lineBuffer, sizeof(lineBuffer), LINK_TIMEOUT_MS)) {
    ++errCount;
    Serial.print(F("LINK NO_REPLY err="));
    Serial.println(errCount);
    delay(1000);
    return;
  }

  uint8_t rxSeq = 0;
  if (sscanf(lineBuffer, "ACK,%hhu", &rxSeq) == 1 && rxSeq == payload) {
    Serial.print(F("LINK OK seq="));
    Serial.print(rxSeq);
    Serial.print(F(" err="));
    Serial.println(errCount);
  } else {
    ++errCount;
    Serial.print(F("LINK BAD_REPLY err="));
    Serial.println(errCount);
  }

  delay(1000);
}
