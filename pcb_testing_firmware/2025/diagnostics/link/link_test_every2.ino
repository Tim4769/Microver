/*
  Arduino Every 2 Link Test (D11/D12 UART)
*/

#include <Arduino.h>
#include <SoftwareSerial.h>
#include <stdio.h>

const uint8_t LINK_RX_PIN = 11;  // D11 receives from Arduino Every 1
const uint8_t LINK_TX_PIN = 12;  // D12 sends to Arduino Every 1
const unsigned long LINK_BAUD = 38400;
SoftwareSerial linkSerial(LINK_RX_PIN, LINK_TX_PIN);

char buffer[24];
size_t indexPos = 0;

void setup() {
  Serial.begin(115200);
  while (!Serial) {
    ;
  }
  pinMode(LINK_TX_PIN, OUTPUT);
  pinMode(LINK_RX_PIN, INPUT);
  linkSerial.begin(LINK_BAUD);
  linkSerial.listen();
  Serial.println(F("Link test slave"));
}

void loop() {
  while (linkSerial.available()) {
    const char c = linkSerial.read();
    if (c == '
') {
      buffer[indexPos] = '';
      uint8_t rxSeq = 0;
      if (sscanf(buffer, "PING,%hhu", &rxSeq) == 1) {
        linkSerial.print(F("ACK,"));
        linkSerial.print(rxSeq);
        linkSerial.print('
');
        Serial.print(F("RX "));
        Serial.println(rxSeq);
      }
      indexPos = 0;
    } else if (indexPos < sizeof(buffer) - 1) {
      buffer[indexPos++] = c;
    }
  }
}
